# Keil uVision project RtxTiny2.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: RtxTiny2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\CH5xx;.\App
  group App
    ./App/: main.c
  group CH5xx
    ./CH5xx/: Debug.c iap.c
  group RtxTiny2
    ./RtxTiny2/: CONF_TNY.A51
